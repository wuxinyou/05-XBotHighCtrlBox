# Keil uVision project XbotUpCtrlBoxV1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: XbotUpCtrlBoxV1 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Includes;.\Includes\App;.\Includes\STM32_CMSIS;.\Includes\STM32_Driver;.\Includes\STM32_LIB;.\Includes\User
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./Source/User/: main.c stm32f10x_it.c STM32_IRQ_FUN.c
    ./Includes/: STM32_IRQ_INIT.h MySysDefine.h
    ./Source/: ReadMe.text
  group App
    ./Source/App/: BatteryAdcRead.c JoyStickAdcRead.c KeyRead.c CbCtrl.c chain.c SwAdcRead.c
  group STM32_Driver
    ./Source/STM32_Driver/: STM32_Adc.C STM32_LedDisp.c STM32_SysTick.C STM32_UsartDriver.c STM32_UsartInit.C STM32_TimInit.C STM32_GpioInit.c STM32_DAC.C
  group STM32_LIB
    ./Source/STM32_LIB/: stm32f10x_dac.c misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group STM32_CMSIS
    ./Source/STM32_CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Includes
    ./Includes/App/: BatteryAdcRead.h JoyStickAdcRead.h KeyRead.h chain.h
    ./Includes/STM32_Driver/: STM32_Adc.h STM32_LedDisp.h STM32_SysTick.h STM32_UsartDriver.h STM32_UsartInit.h
