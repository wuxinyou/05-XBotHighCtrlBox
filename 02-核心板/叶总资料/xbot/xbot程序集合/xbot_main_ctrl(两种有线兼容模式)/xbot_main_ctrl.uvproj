# Keil uVision project xbot_main_ctrl.uvproj, settings and files
target Xbot510_MainCtrl (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: xbot_main_ctrl +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: .\Includes\App;.\Includes\Protocol;.\Includes\STM32_CMSIS;.\Includes\STM32_Driver;.\Includes\STM32F4_StdPeriph;.\Includes\User;.\Includes\DataTypeRealize;.\Includes
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./source/User/: system_stm32f4xx.c main.cpp STM32_IRQ_FUN.cpp
  group App
    ./source/App/: XbotApp.cpp
  group Protocol
    ./source/Protocol/: BaseControl.cpp CodedDiscControl.cpp MotorControl.cpp PowerControl.cpp TerminalControl.cpp OtherDeviceControl.cpp GpsImucontrol.cpp OpticalBobbin.cpp
  group DataTypeRealize
    ./source/DataTypeRealize/: DataChain.cpp SerialPort.cpp LEDLighter.cpp Timer.cpp WatchDog.cpp
  group STM32_Driver
    ./source/STM32_Driver/: STM32F4_UsartIrq.c STM32F4_UsartInit.C STM32F4_UsartDriver.c STM32F4_PriorityControl.c STM32F4_SysTick.C STM32_Adc.C
  group SEM32F4_StdPeriph
    ./source/STM32F4_StdPeriph/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4_CMSIS
    ./source/STM32_Driver/: STM32F4_GpioInit.c
    ./source/STM32_CMSIS/: startup_stm32f4xx.s
  group Redme
    ./source/Help/: Help.txt
